File: SSRexpander8.kicad_sch (KiCad schematic)
At the start: 35 parts

Commit message: Grid issues
Other:
- moved on the sheet: C?, D?, J?, R?, U?
