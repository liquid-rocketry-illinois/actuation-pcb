File: LimitSwitchExpander8.kicad_sch (KiCad schematic)
At the start: 27 parts

Commit message: Grid issues
Other:
- moved on the sheet: C?, J?, R?, U?
